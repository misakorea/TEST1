# Keil uVision project AIR.uvprojx, settings and files
target AIR (ARM-ADS)
  device: STM32L151RBxxA STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: AIR
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L151xBA
  c misc: --C99
  c include: ../Inc;       ../Drivers/STM32L1xx_HAL_Driver/Inc;       ../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;       ../Drivers/CMSIS/Device/ST/STM32L1xx/Include;       ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32l151xba.s
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_cortex.c stm32l1xx_hal_flash.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_spi.c stm32l1xx_hal_rcc.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_dma.c stm32l1xx_hal_pwr.c stm32l1xx_hal_gpio.c stm32l1xx_hal_uart.c stm32l1xx_hal_tim.c
  group Application/User
    ../Src/: gpio.c spi.c stm32l1xx_it.c dma.c stm32l1xx_hal_msp.c usart.c main.c
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
software components: CMSIS:CORE 4.1.0
